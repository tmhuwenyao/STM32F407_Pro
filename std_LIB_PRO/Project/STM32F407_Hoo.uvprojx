# Keil uVision project STM32F407_Hoo.uvprojx, settings and files
target STM32F407 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407_Hoo
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\FWLIB\src;..\User;..\User\led;..\Libraries\FWLIB\inc;..\User\drivers\tim;..\User\apps\dht11;..\User\apps\w25qxx_flash;..\User\apps\dotmatrix;..\User\drivers\inc;..\User\apps\modbuscomm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ../Libraries/CMSIS/startup/: startup_stm32f40_41xxx.s
  group cmsis
    ../Libraries/CMSIS/: system_stm32f4xx.c
  group fwlib
    ../Libraries/FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group user
    ../User/: main.c stm32f4xx_it.c bsp.c
    ../User/drivers/src/: bsp_systick.c bsp_led.c bsp_rtc.c bsp_usart.c bsp_tim.c ST_string.c
  group doc
    ../Doc/: readme.txt
  group app
    ../User/apps/dht11/: hoo_dht11.c
    ../User/apps/w25qxx_flash/: hoo_w25qxx.c
    ../User/apps/dotmatrix/: hoo_dotmatrix.c
    ../User/apps/modbuscomm/: hoo_modbuscomm.c
    ../User/apps/stepmotor/: hoo_stepmotor.c
